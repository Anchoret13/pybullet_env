Commit message: submodule update
Signed-off-by: Spike <vergil1133@live.com>

File: urdf/ur5_robotiq_85.urdf (robot description, URDF)
Before this commit: robot ur5_robotiq_85, 20 links, 19 joints
Links:
- removed link world
Joints:
- removed joint world_arm_joint
