Commit message: updated
Signed-off-by: anchoret13 <vergil1133@live.com>

File: urdf/ball_test.urdf (robot description, URDF)
Before this commit: robot simple_ball, 1 links, 0 joints
Links:
- link ball: geometry collision sphere radius=0.04; visual sphere radius=0.04
